# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: Project.c
